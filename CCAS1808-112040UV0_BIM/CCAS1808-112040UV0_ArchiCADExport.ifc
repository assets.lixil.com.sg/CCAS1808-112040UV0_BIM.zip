Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-07T10:59:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 07 10:59:42 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\9bd67d5c-aa35-4c4a-bd99-d24956ca2a11\4061e56d-7eed-4236-8321-4e1564a93dc7\ifc * Database version: 5507 * Database creation date: Sat Sep 07 10:59:35 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 07 10:59:35 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 07 10:59:36 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_348335 | SINK
Port_348335 | SOURCE

# IfcFlowTerminal: CCAS1808-112040UV0_REVIT:Acacia E Vortex OP 2.6/4L CBR Slow SC WT, CCAS1808-112040UV0_REVIT:Acacia E Vortex OP 2.6/4L CBR Slow SC WT:348335
In: Level 1
Type - Material: <Unnamed>, American Standard - Vitreous China
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Acacia E Vortex OP 2.6/4L CBR Slow SC WT
Material: American Standard - Vitreous China, Steel, Chrome Plated, American Standard - Gray
Pset_DistributionFlowElementCommon - Reference: Acacia E Vortex OP 2.6/4L CBR Slow SC WT; sets with these values: 2
